# Keil uVision project traffic-light-ms51.uvproj, settings and files
target traffic-light (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: traffic_light_ms51 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\Library\Device\Include;.\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group src
    ./src/: helloworld.c driver.c logic_master.c driver_led.SRC driver_led.c
  group Library
    ./Library/StdDriver/src/: sys.c common.c delay.c
  group Startup
    ./Library/Startup/KEIL/: STARTUP.A51
